options:
  parameters:
    generate_options: qt_gui
    id: Openlab
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.2'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: packet_utils_packet_rx_continuous_0
  id: packet_utils_packet_rx_continuous
  parameters:
    samples_per_symbol: '2'
    sensitivity: '1.0'
    sync_word: '0xDEADBEEF'
  states: {}
- name: packet_utils_packet_tx_continuous_0
  id: packet_utils_packet_tx_continuous
  parameters:
    bt: '0.35'
    preamble: '0xAAAAAAAA'
    samples_per_symbol: '2'
    sensitivity: '1.0'
    sync_word: '0xDEADBEEF'
  states: {}
- name: packet_utils_smart_multimedia_sink_0
  id: packet_utils_smart_multimedia_sink
  parameters:
    filename: /Users/harishankar/Documents/Openlab/videos/1080p_output.mp4
  states: {}
- name: packet_utils_smart_multimedia_source_0
  id: packet_utils_smart_multimedia_source
  parameters:
    filename: /Users/harishankar/Documents/Openlab/videos/1080p.mp4
    image_quality: '75'
    repeat: 'False'
    video_bitrate: 500k
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_throttle2_0, '0', packet_utils_packet_tx_continuous_0, '0']
- [channels_channel_model_0, '0', packet_utils_packet_rx_continuous_0, '0']
- [packet_utils_packet_rx_continuous_0, '0', packet_utils_smart_multimedia_sink_0, '0']
- [packet_utils_packet_tx_continuous_0, '0', channels_channel_model_0, '0']
- [packet_utils_packet_tx_continuous_0, '0', uhd_usrp_sink_0, '0']
- [packet_utils_smart_multimedia_source_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_sink_0, async_msgs, uhd_usrp_source_0, command]
- [uhd_usrp_source_0, '0', packet_utils_packet_rx_continuous_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
